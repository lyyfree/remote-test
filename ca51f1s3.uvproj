# Keil uVision project ca51f1s3.uvproj, settings and files
target CA51F (MCS-51)
  device: R8051XC2 CAST, Inc.
  cpu: IRAM(0-0xFF) CLOCK(24000000)  MOD517DP MDU_R515
  output: ca51f1s3 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\include;.\source;.\source\device;.\source\driver;.\source\mcu_sdk
  link misc: REMOVEUNUSED
  group Lib
    ./lib/: STARTUP.A51
  group include
    ./include/: ca51f1s3_config.h ca51f1s3sfr.h ca51f1s3xsfr.h delay.h gpiodef_f1s3.h system_clock.h uart.h
  group src/driver
    ./source/driver/: delay.c system_clock.c uart.c int.c int.h timer.c timer.h key.c key.h
  group src
    ./source/: interrupt.c main.c headfile.h
  group src/mcu_sdk
    ./source/mcu_sdk/: mcu_api.c mcu_api.h offline_voice_word_zh_cn.h protocol.c protocol.h system.c system.h tuya_type.h wifi.h
